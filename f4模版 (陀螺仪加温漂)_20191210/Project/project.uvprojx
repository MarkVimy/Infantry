# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --C99
  c include: ..\AppInfo;..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\SYSTEM;..\mpu6050;..\mpu6050\eMPL;..\Temperature;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\TASK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group AppInfo
    ../AppInfo/: judge.c vision.c
  group APP
    ../APP/: main.c stm32f4xx_it.c kalman.c remote.c friction.c magzine.c crc.c my_app.h kalman_filter.c
  group BSP
    ../BSP/: led.c exti.c init.c can.c pwm.c uart5.c laser.c uart4.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/cmsis/: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/: my_include.h sys.c scheduler.c delay.c usart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group MPU6050
    ../mpu6050/: myiic.c mpu6050.c
    ../mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Temperature
    ../Temperature/: temp.c
  group Task
    ../TASK/: my_task.h Task_Chassis.c Task_Gimbal.c Task_Timing_Report.c Task_Revolver.c
  group Readme
    ../README/: log.txt
  group Drivers/CMSIS
    ../Libraries/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
